# Keil uVision project CCM4202S_DEMO.uvprojx, settings and files
target DEBUG_EFM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ccm4202s_demo_efm +hex
  AfterMake: fromelf --bin --output ..\obj\bin\CCM4202S_Demo_EFM.bin ..\obj\obj_debug_efm\ccm4202s_demo_efm.axf
  AfterMake: fromelf --text -a -c --output ..\obj\hex\CCM4202S_Demo_EFM.asm ..\obj\obj_debug_efm\ccm4202s_demo_efm.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,__CC_ARM,MBEDTLS_BASE64_C
  c misc: --gnu
  c include: ..\Src\Include;..\Src\Source\app;..\Src\Source\ccore;..\Src\Source\common;..\Src\Source\demo;..\Src\Source\drv;..\Src\Source\drv\inc;..\Src\Source\app\apdu;..\Src\Source\app\icc;..\Src\Source\app\nfc;..\Src\Source\app\dac_audio;..\Src\Source\app\timestamp;..\Src\Source\app\tsi;.\main;..\Src\Source\app\adpcm;..\Src\Source\app\MRW SENSOR\bin_interface;..\Src\Source\app\MRW SENSOR\bsp;..\Src\Source\app\MRW SENSOR\inc;..\Src\Source\app\MRW SENSOR\lib;..\Src\Source\app\MRW SENSOR\misc;..\Src\Source\app\MRW SENSOR;..\Src\Source\ModuleDrv;..\Src\Source\segger_rtt;..\Src\Source\ModuleHal;..\Src\Source\Lock\Menu;..\Src\Source\Lock\ModuleDrv;..\Src\Source\Lock\ModuleHal;..\Src\Source\Lock\segger_rtt;..\Src\Source\Lock\UserApp;..\Src\Source\Lock\cm_backtrace;..\Src\Source\Lock\cm_backtrace\fault_handler;..\Src\Source\Lock\cm_backtrace\fault_handler\keil;..\Src\Source\Lock\basicFunc;..\Src\Source\Lock\hostlib
  memory RVCT4: ROM 0x800a000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x38000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group main
    ./main/: main.c Test.txt
  group UserApp
    ../Src/Source/Lock/UserApp/: APP_Power.c AppUser.c Function.c
  group UserMenu
    ../Src/Source/Lock/Menu/: Menu_KeyBackLight.c Menu_KeyDeal.c Menu.h Menu.c Maths.c Menu_CycleScanMenu.c Menu_DataStructure.c Menu_GetInputInfo.c Menu_WhenEnterMenuOperation.c Menu_Finger.c Menu_WhenExitMenuOperation.c Menu_CurrentOperate.h Menu_CurrentOperate.c Menu_Face.c Menu_Voice.c Menu_Comm.c Menu_Wifi.c
  group ModuleHal
    ../Src/Source/Lock/ModuleHal/: HAL_Comm.c HAL_Comm.h HAL_FaceId.c HAL_FaceId.h HAL_SysTimer.c HAL_SysTimer.h HAL_KeyLight.c HAL_KeyLight.h HAL_KeySacn.C HAL_KeySacn.h HAL_Power.c HAL_Power.h HAL_Voice.c HAL_Voice.h HAL_Storage.c HAL_Storage.h HAL_Finger.c HAL_Finger.h HAL_RTC.c HAL_RTC.h HAL_Adc.c HAL_Adc.h HAL_Alarm.c HAL_Alarm.h HAL_IR.c HAL_IR.h HAL_BreathingLight.h HAL_Motor.h HAL_OnChipFlash.c HAL_OnChipFlash.h
  group ModuleDrv
    ../Src/Source/Lock/ModuleDrv/: MyConfig.h DRV_FaceId.c DRV_FaceId.h DRV_MBI5024.C DRV_MBI5024.h MD5.c MD5.h MyConfig.c rijndael.c rijndael.h DRV_SysTimer.c DRV_SysTimer.h DRV_KeySacn.c DRV_KeySacn.h DRV_Voice.c DRV_Voice.h DRV_Storage.c DRV_Storage.h DRV_Finger.c DRV_Finger.h DRV_RTC.c DRV_RTC.h DRV_Comm.c DRV_Comm.h DRV_Adc.c DRV_Adc.h DRV_Alarm.c DRV_Alarm.h DRV_Power.c DRV_Power.h DRV_IR.c DRV_IR.h DRV_I2C.c DRV_I2C.h DRV_EEPROM.h DRV_Motor.h drv_spi.h I2C_CM3.h W25QXX.h DRV_OnChipFlash.c DRV_OnChipFlash.h
  group basicFunc
    ../Src/Source/Lock/basicFunc/: BasicFunc.c BasicFunc.h
  group ID2
    ../Src/Source/Lock/hostlib/: aes.c aes.h ali_crypto.h ali_crypto_types.h api_aes.c api_hash.c api_hmac.c api_init.c api_rand.c api_rsa.c api_sm2.c api_sm4.c asn1.h base64.c base64.h bignum.c bignum.h bn_mul.h chip_config.h chip_log.c chip_log.h config.h dpm.h dpm_core.c dpm_plat.c dpm_plat.h dpm_sha256.c dpm_sha256.h i2c_a7.c i2c_a7.h id2_client.c id2_client.h id2_config.h id2_plat.c id2_plat.h id2_priv.h id2_util.c irot_hal.h km.h km_to_irot.c ls_hal.h ls_hal_aes.c ls_hal_aes.h ls_hal_crypt.h ls_hal_hash.c ls_hal_hash.h ls_hal_km.h ls_hal_rand.c ls_hal_rsa.c ls_hal_rsa.h ls_hal_sst.h ls_osa.c ls_osa.h md.h md5.c md5.h mtk_se_adapter.c oid.h otp.c pk.h rsa.c rsa.h se_driver.c se_driver.h sha1.c sha1.h sha256.c sha256.h std_se_adapter.c timer.c timer.h unistd.h
  group demo
    ../Src/Source/demo/: adc_demo.c algo_demo.c apdu_demo.c bt_demo.c ccm_demo.c cpm_demo.c crc_demo.c disboot_demo.c dma_demo.c edma_demo.c eflash_demo.c eport_demo.c get_sn_demo.c i2c_demo.c icc_demo.c mcc_demo.c nfc_demo.c pci_demo.c pit32_demo.c pwm_demo.c reboot_demo.c reset_demo.c rtc_demo.c spi_demo.c sub_c0_demo.c tc_demo.c tsi_demo.c uart_demo.c usb_cdc_demo.c usb_demo.c usb_hid_demo.c usb_ms_demo.c wdt_demo.c systick_demo.c dsp_demo.c dac_demo.c lock_disjtag_demo.c ssi_demo.c xip_demo.c mrw_demo.c
  group common
    ../Src/Source/common/: common.c debug.c delay.c sys.c
  group ccore
    ../Src/Source/ccore/: system_ARMCM4.c startup_ARMCM4.s
  group drv
    ../Src/Source/drv/: adc_dma.c adc_drv.c alg_drv.c dac_drv.c c0_drv.c cache_drv.c ccm_drv.c dmac_drv.c edma_drv.c eflash_drv.c eport_drv.c i2c_drv.c crc_drv.c pci_drv.c cpm_drv.c pit32_drv.c pwm_drv.c reset_drv.c rtc_drv.c spi_drv.c tc_drv.c uart_drv.c usi_drv.c wdt_drv.c systick_drv.c ssi_drv.c xip_drv.c trng_drv.c ioctrl_drv.c tsi_drv.c
    ../Src/Source/drv/usb/: usb_cdc_config.c usb_cdc_control.c usb_drv.c usb_hid_config.c usb_hid_control.c usb_hid_isr.c usb_ms_config.c usb_ms_control.c usbdev_control.c usbdev_isr.c
  group lib
    ../Src/Source/lib/: libBT_ATT8761.lib libEFlash.lib libGetSN.lib libMCC.lib libAlgorithm.lib arm_cortexM4_math.lib libClkSwitch.lib libTSI.lib libLockJtag.lib libRegOpt.lib libadpcm.lib eflash_lib.lib
  group MRW SENSOR
    ../Src/Source/app/MRW SENSOR/bin_interface/: bin_lib_table.c
    ../Src/Source/app/MRW SENSOR/bsp/: Cache.c ClockAndPower.c Flash.c GPIO.c Timeout.c Timer.c Uart.c SensorSpi.c Sensor.c
    ../Src/Source/app/MRW SENSOR/lib/: DMA.c EDMA.c EPORT.c PIT.c SCI.c SPI.c SSI.c
    ../Src/Source/app/MRW SENSOR/: fsm.c system.c
  group RTT
    ../Src/Source/Lock/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group app
    ../Src/Source/app/apdu/: apdu_dispatcher.c apdu_drv.c aes_drv.c aes_drv.h aes_reg.h apdu.h apdu_algo_cmd.c apdu_basic_cmd.c apdu_commands.h apdu_dispatcher.h apdu_drv.h des_drv.c des_drv.h des_reg.h id2.h id2_client.h id2_test.h sha_drv.c sha_drv.h sha_reg.h sm.c sm.h
    ../Src/Source/app/dac_audio/: dac_audio.c
    ../Src/Source/app/icc/: icc_hardware.c icc_protocol.c iccemv.c
    ../Src/Source/app/nfc/: fm175xx.c emv_layer4.c iso14443a.c iso14443b.c pcd_interface.c
    ../Src/Source/app/timestamp/: time_stamp_api.c
    ../Src/Source/app/tsi/: tsi_app.c tsi_hal.c
  group cm_backtrace
    ../Src/Source/Lock/cm_backtrace/: cm_backtrace.c
    ../Src/Source/Lock/cm_backtrace/fault_handler/keil/: cmb_fault.S
target DEBUG_RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ccm4202s_demo_ram
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,__CC_ARM
  c misc: --gnu
  c include: ..\Src\Include;..\Src\Source\app;..\Src\Source\ccore;..\Src\Source\common;..\Src\Source\demo;..\Src\Source\drv;..\Src\Source\drv\inc;..\Src\Source\app\apdu;..\Src\Source\app\icc;..\Src\Source\app\nfc;..\Src\Source\app\dac_audio;..\Src\Source\app\tsi;..\Src\Source\app\timestamp;.\main
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x20020000 size 0x18000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
